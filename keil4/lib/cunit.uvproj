# Keil uVision project cunit.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1778 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ..\cunit2.1 (library)
  c flags: Optim=1
  c include: ..\..\Headers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_LPC177x_8x.s
  group source
    ../../Sources/Automated/: Automated.c
    ../../Sources/Basic/: Basic.c
    ../../Sources/Console/: Console.c
    ../../Sources/Framework/: CUError.c MyMem.c TestDB.c TestRun.c Util.c
    ../../Sources/Test/: test_cunit.c
